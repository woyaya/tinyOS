# Keil uVision project scheduler.uvproj, settings and files
target scheduler (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: scheduler +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,IRAM_SIZE=0x5000,IRAM_BASE=0x20000000
  c misc: --enum_is_int
  c include: ..\header;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\STM32F10x_StdPeriph_Template;..\source
  asm misc: --cpreproc --diag_warning 1546
  asm include: ..\header;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group source
    ../source/: scheduler.c semaphore.c platform.S startup_stm32f10x_md.s
  group header
    ../header/: semaphore.h semaphore_share.h scheduler.h list.h config.h platform.h
    ../../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h
  group test
    ../test/: test.c
  group Libraries
    ../../STM32F10x_StdPeriph_Template/: system_stm32f10x.c stm32f10x_it.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_rtc.c misc.c
